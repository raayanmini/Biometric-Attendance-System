# Keil uVision project BAS_FP.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BAS_FP
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./src/: FP_gt521f32.c UART1.c systemticktimer.c km_lcd.c gpio.c 4x4_keypad.c Interrupt.c my_string.c
    ./inc/: FP_gt521f32.h stm32f401rbt6.h UART1.h systemticktimer.h km_lcd.h gpio.h 4x4_keypad.h Interrupt.h my_string.h
    ./: main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.6.3
